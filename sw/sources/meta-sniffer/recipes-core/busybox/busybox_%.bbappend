FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://devmem.cfg"