do_configure[depends] += 'bitstream-extraction:do_deploy'
