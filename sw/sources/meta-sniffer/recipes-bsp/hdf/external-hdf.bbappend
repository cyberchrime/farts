FILESEXTRAPATHS:prepend := "${THISDIR}:"

HDF_EXT = "xsa"
HDF_BASE = "file://"
HDF_PATH = "fpga.xsa"

SRC_URI = "${HDF_BASE}${HDF_PATH}"
